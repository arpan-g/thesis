<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ILC_8x8_positioning_ED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


