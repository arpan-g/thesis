# IAR project Backup of ILC_8x8_positioning_ED.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.newCCIncludePaths: ..\drivers\bsp; ..\drivers\bsp\drivers; ..\drivers\bsp\boards\EZ430RF; ..\drivers\mrfi
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group Application
    ./: main_ILC_8x8_positioning_ED.c
  group Components/bsp
    ../drivers/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../drivers/mrfi/: mrfi.c mrfi.h mrfi_defs.h
